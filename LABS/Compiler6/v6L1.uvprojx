# Keil uVision project v6L1.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: v6L1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=7
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
